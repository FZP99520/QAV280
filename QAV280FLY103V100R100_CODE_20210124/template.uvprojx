# Keil uVision project template.uvprojx, settings and files
target Target1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: .\USER;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\LED;.\APP\USART;.\APP\systick;.\APP\PRINTF;.\APP;.\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group APP
    ./APP/LED/: led.c
    ./APP/systick/: systick.c
    ./APP/: clock.c ms5611.c mpu6050.c qmc5883.c control.c nrf24l01.c RC.c gps.c ANO_DT.c flash.c filter.c IMU.c ahrs.c height.c Position_Control_GPS.c
    ./APP/PRINTF/: printf.c
  group drive
    ./Drive/: iic.c pwm.c timer.c spi.c exti.c usart.c dma.c adc.c kalman.c driver.c
    ./APP/: pid.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_i2c.c
  group cmsis
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6
